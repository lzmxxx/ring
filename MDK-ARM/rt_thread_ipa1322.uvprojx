# Keil uVision project rt_thread_ipa1322.uvprojx, settings and files
target N32WB452_BLE_RTOS (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.2.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: N32WB452_BLE_RTOS +hex
  AfterMake: fromelf --bin --output=.\bin\N32WB452_BLE_RTOS.bin .\Objects\N32WB452_BLE_RTOS.axf
  AfterMake: G:\5-研究生（生医工）\8-可穿戴\血氧戒指定\嵌入式代码\rt_thread_ipa1322_cw2015\MDK-ARM\keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER, N32WB452_BT_API, N32WB452XL_EVB, HSE_VALUE=32000000, ARM_MATH_CM4, __FPU_PRESENT=1, __DSP_PRESENT=1, USE_RTT
  c misc: --wchar16
  c include: ..\Start;..\Library\inc;..\RTOS\include;..\RTOS;..\User;..\mydrivers\Board;..\mydrivers\Power;..\mydrivers\MyI2C;..\mydrivers\MyI2C2;..\mydrivers\MySPI2;..\mydrivers\CW2015;..\mydrivers\SC7A20;..\mydrivers\IPA1322;..\mydrivers\SpO2;..\BLE_Driver\inc;..\BLE_Driver\api\inc;..\BLE_Driver\profile\inc;..\BLE_Driver\platform\inc;..\BLE_Driver;..\BLE_Driver\bsp;..\segger_systemview;..\segger_rtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4e000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../Start/: startup_n32wb452.s
  group CMSIS
    ../Start/: system_n32wb452.c
  group FWLB
    ../Library/src/: misc.c n32wb452_bkp.c n32wb452_dbg.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_tim.c n32wb452_usart.c n32wb452_i2c.c n32wb452_spi.c n32wb452_dma.c
  group APPLICATION
    ../User/: app_main.c app_ppg.c app_ble.c app_packet.c app_spo2.c app_power.c app_device.c app_protocol.c app_record.c interrupt.c app_config.h
  group MYDRIVERS
    ../mydrivers/Power/: bsp_power.c
    ../mydrivers/MyI2C/: bsp_hw_i2c.c bsp_i2c.c
    ../mydrivers/IPA1322/: IPA1322.c vt2102_hal.c
    ../mydrivers/SpO2/: SpO2.c SpO2_advanced.c
    ../mydrivers/MyI2C2/: MyI2C2.c
    ../mydrivers/MySPI2/: MySPI2.c
    ../mydrivers/CW2015/: CW2015.c
    ../mydrivers/SC7A20/: SC7A20.c
  group BSP
    ../mydrivers/Board/: board.c clock.c
  group RTOS
    ../RTOS/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
    ../RTOS/libcpu/: cpuport.c context_rvds.S
  group BLE_STACK
    ../BLE_Driver/: n32wb452_ble_api.c hl_test.c
    ../BLE_Driver/api/src/: n32wb452_data_fifo.c
    ../BLE_Driver/profile/src/: app.c app_batt.c app_sec.c app_task.c app_user.c bass.c bass_task.c prf.c prf_utils.c user.c user_task.c
    ../BLE_Driver/platform/src/: Eif_debug.c Eif_flash.c Eif_timer.c Interface.c
    ../BLE_Driver/bsp/: bsp_timer.c log.c
  group LIB
    ../Library/DSP/Lib/: arm_cortexM4lf_math.lib
    ../BLE_Driver/lib/Keil/: host_16bit.lib n32wb452_ble_16bit.lib
  group SEGGER_RTT
    ../segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c rtt_heartbeat_template.c SEGGER_RTT.h SEGGER_RTT_Conf.h
